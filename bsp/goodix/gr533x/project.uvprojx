# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf.exe --text -c --output build\keil\List\@L.s   build\keil\Obj\@L.axf
  AfterMake: fromelf.exe --bin --output build\keil\List\@L.bin build\keil\Obj\@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ENV_USE_RT_THREAD
  c include: ..\..\..\sdk\GR533x\components\drivers_ext;..\..\..\sdk\GR533x\components\libraries\app_alarm;..\..\..\sdk\GR533x\components\libraries\app_assert;..\..\..\sdk\GR533x\components\libraries\app_error;..\..\..\sdk\GR533x\components\libraries\app_key;..\..\..\sdk\GR533x\components\libraries\app_log;..\..\..\sdk\GR533x\components\libraries\app_timer;..\..\..\sdk\GR533x\components\libraries\pmu_calibration;..\..\..\sdk\GR533x\components\libraries\utility;..\..\..\sdk\GR533x\components\libraries\dfu_port;..\..\..\sdk\GR533x\components\libraries\ring_buffer;..\..\..\sdk\GR533x\components\sdk;..\..\..\sdk\GR533x\platform\arch\arm\cortex-m\keil;..\..\..\sdk\GR533x\platform\arch\arm\cortex-m\cmsis\core\include;..\..\..\sdk\GR533x\platform\boards;..\..\..\sdk\GR533x\platform\include;..\..\..\sdk\GR533x\platform\soc\common;..\..\..\sdk\GR533x\platform\soc\include;..\..\..\sdk\GR533x\platform\soc\linker\keil;..\..\..\sdk\GR533x\components\libraries\hal_flash;..\..\..\sdk\GR533x\drivers\inc\hal;..\..\..\sdk\GR533x\drivers\inc;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers;..\..\..\components\drivers\i2c;..\..\..\components\drivers\include\drivers;..\..\..\components\drivers\include;..\..\..\components\drivers\pm;..\..\..\components\drivers\spi;..\..\..\components\drivers\serial;..\..\..\components\drivers\i2c;..\..\..\components\libc\compilers\common\nogcc;..\..\..\include;.\applications;.\applications\config;.\applications\user;..\gr533x;.\board
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\sdk\GR533x\platform\soc\linker\keil\flash_scatter_common.sct
  link misc: ..\..\..\sdk\GR533x\platform\soc\linker\keil\rom_symbol.txt
  group Applications
    applications/: main.c
    ./applications/user/: user_app.c user_app.h user_periph_setup.c user_periph_setup.h
    ./applications/config/: ble_basic_config.h custom_config.h
  group GR_SoC
    ../../../sdk/GR533x/platform/arch/arm/cortex-m/keil/: Startup.S
    ../../../sdk/GR533x/platform/soc/src/: gr_soc.c
    ../../../sdk/GR533x/platform/soc/common/: gr_interrupt.c gr_platform.c gr_system.c
  group GR_Lib
    ../../../sdk/GR533x/platform/soc/linker/keil/: ble_sdk.lib
  group CPU
    ../../../libcpu/arm/common/: showmem.c backtrace.c div0.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Kernel
    ../../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group UtilsDrivers
    ../../../components/drivers/src/: pipe.c dataqueue.c completion.c workqueue.c ringbuffer.c waitqueue.c ringblk_buf.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c
  group Drivers
    ../../../sdk/GR533x/platform/boards/: board_SK.c
    ./board/: board.c pm.c
  group DriverPorting
    ./board/: drv_porting.h drv_porting_pin.h drv_porting_pin.c drv_porting_spi.h drv_porting_spi.c drv_porting_uart.h drv_porting_uart.c drv_porting_i2c.h drv_porting_i2c.c pin_test.c i2c_test.c spi_test.c uart_test.c
  group DriverLibraries
    ../../../sdk/GR533x/drivers/src/: app_io.c app_gpiote.c app_i2c.c app_i2c_dma.c app_spi.c app_spi_dma.c app_uart.c app_uart_dma.c app_dma.c app_pwr_mgmt.c app_rtc.c
  group DriverUtils
    ../../../sdk/GR533x/components/libraries/utility/: utility.c
    ../../../sdk/GR533x/components/libraries/app_timer/: app_timer.c
    ../../../sdk/GR533x/components/libraries/pmu_calibration/: pmu_calibration.c
    ../../../sdk/GR533x/components/libraries/app_key/: app_key.c app_key_core.c
    ../../../sdk/GR533x/components/libraries/app_error/: app_error.c
    ../../../sdk/GR533x/components/libraries/app_assert/: app_assert.c
    ../../../sdk/GR533x/components/libraries/app_log/: app_log.c
    ../../../sdk/GR533x/components/libraries/ring_buffer/: ring_buffer.c
    ../../../sdk/GR533x/components/sdk/: ble.c
